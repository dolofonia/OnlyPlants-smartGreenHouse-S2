# Keil uVision project leeg_test.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: leeg_test
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CLOCK_SETUP=1
  c misc: -Wno-gnu-binary-literal -Wno-missing-prototypes -Wno-missing-noreturn -Wno-sign-conversion -Wno-declaration-after-statement
  c include: .\aht21b;.\I2C0;.\queue;.\uart0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./SRC/: main.c
  group aht21b
    ./aht21b/: aht21b.c aht21b.h
  group i2c
    ./I2C0/: i2c0.c i2c0.h
  group uart
    ./queue/: queue.c queue.h
    ./uart0/: uart0.c uart0.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
