# Keil uVision project shield-oled.uvprojx, settings and files
target Shield (6190000::V6.19::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: shield-oled
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CLOCK_SETUP=1
  c misc: -Wno-gnu-binary-literal -Wno-missing-prototypes -Wno-missing-noreturn -Wno-sign-conversion -Wno-declaration-after-statement -Wno-unused-function
  c include: ./bsp;./bsp/delay;./bsp/oled;.\bsp\menu;.\bsp\switches
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group bsp
    ./bsp/: bsp.h
  group bsp\delay
    ./bsp/delay/: delay.c delay.h
  group bsp\oled
    ./bsp/oled/: bitmaps.c bitmaps.h fonts.c fonts.h i2c1.h i2c1.c ssd1306.c ssd1306.h
  group src
    ./src/: main.c
  group bsp\menu
    ./bsp/menu/: menu.c menu.h
  group bsp\swiches
    ./bsp/switches/: switches.c switches.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.5.0
