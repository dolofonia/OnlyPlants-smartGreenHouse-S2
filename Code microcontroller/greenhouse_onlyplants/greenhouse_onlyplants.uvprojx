# Keil uVision project greenhouse_onlyplants.uvprojx, settings and files
target CMSIS-DAP (6190000::V6.19::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: greenhouse_onlyplants
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CLOCK_SETUP=1
  c misc: -Wno-gnu-binary-literal -Wno-missing-prototypes -Wno-missing-noreturn -Wno-sign-conversion -Wno-declaration-after-statement
  c include: .\scr;.\switches;.\uart0;.\queue;.\datanodered;.\fan;.\LEDS;.\HEATBED;.\battery;.\pump;.\controll;.\bsp\delay;.\bsp\docs;.\bsp\menu;.\bsp\oled;.\bsp\switches;.\bsp;.\I2C1;.\aht21b;.\mistmodule;.\lichtmodule;.\soilMoisture;.\wlevel
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group scr
    ./scr/: main.c
  group switches
    ./switches/: switches.c switches.h
  group queue
    ./queue/: queue.c queue.h
  group uart0
    ./uart0/: uart0.c uart0.h
  group datanodered
    ./datanodered/: datanodered.c datanodered.h
  group fan
    ./fan/: fan.c fan.h
  group LEDS
    ./LEDS/: LEDS.c LEDS.h
  group HEATBED
    ./HEATBED/: HEATBED.c HEATBED.h
  group battery
    ./battery/: battery.c battery.h
  group pump
    ./pump/: pump.c pump.h
  group controll
    ./controll/: controll.c controll.h
  group Oled
    ./bsp/menu/: menu.c menu.h
    ./bsp/delay/: delay.c delay.h
    ./bsp/oled/: bitmaps.c bitmaps.h fonts.c fonts.h i2c1.c i2c1.h ssd1306.c ssd1306.h
    ./bsp/: bsp.h
  group aht21b
    ./aht21b/: aht21b.c aht21b.h
    ./I2C1/: i2c0.c i2c0.h
  group mistmodule
    ./mistmodule/: mistmodule.c mistmodule.h
  group ldr
    ./lichtmodule/: lichtmodule.c lichtmodule.h
  group soil mositure
    ./soilMoisture/: soilmoisture.c soilmoisture.h
  group waterlvl
    ./wlevel/: wlevel.h wlevel.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
